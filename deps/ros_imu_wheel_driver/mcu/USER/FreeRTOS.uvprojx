# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --locale=english
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\SPI;..\HARDWARE\USART2;..\CONFIG;..\HARDWARE;..\COMMUNICATE;..\COMMON;..\HARDWARE\BSP;..\HARDWARE\EXIT;..\HARDWARE\MultiButton;..\HARDWARE\ADC;..\HARDWARE\PID;..\HARDWARE\TIMER;..\HARDWARE\GPIO;..\IMU;..\IMU\BMI160;..\MOTOR;..\MOTOR\PID;..\PUBLIC;..\USMART;..\Application;..\Shell;..\HARDWARE\IIC;..\HARDWARE\BQ24773;..\HARDWARE\USART3;..\HARDWARE\BMI08x-Sensor-API-master;..\HARDWARE\BMI08x-Sensor-API-master\examples\generic\common;..\HARDWARE\BMI08x-Sensor-API-master\examples\generic\read_sensor_data
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/BSP/: bsp.c
    ../HARDWARE/GPIO/: bsp_gpio.c
    ../HARDWARE/EXIT/: bsp_exti.c
    ../HARDWARE/USART2/: bsp_uart2.c
    ../HARDWARE/TIMER/: bsp_timer.c bsp_timer_capture.c
    ../HARDWARE/USART3/: bsp_usart3.c
    ../HARDWARE/IIC/: myiic.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart1.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_tim.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group IMU
    ../HARDWARE/IIC/: bmi088.c BMI088_Task.c
    ../HARDWARE/BMI08x-Sensor-API-master/: bmi08a.c bmi08g.c
    ../HARDWARE/BMI08x-Sensor-API-master/examples/generic/common/: bmi08x_common.c
    ../HARDWARE/BMI08x-Sensor-API-master/examples/generic/read_sensor_data/: read_sensor_data.c
  group MOTOR
    ../MOTOR/: motor.c encoder.c direct.c
  group COMMUNICATE
    ../COMMUNICATE/: FrameHandle.c protocol.c protocol_uart1.c
  group COMMON
    ../COMMON/: debug_assert.c monitor.c
  group SHELL
    ../Shell/: cmd.c read-line.c shell.c syslog.c
